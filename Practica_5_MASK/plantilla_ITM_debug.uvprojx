# Keil uVision project plantilla_ITM_debug.uvprojx, settings and files
target plantilla_ITM_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: plantilla_ITM_debug
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .;..\terceros\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\Include;..\terceros\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include;..\terceros\STM32F4-Discovery_FW_V1.1.0\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\terceros\STM32F4-Discovery_FW_V1.1.0\Utilities\STM32F4-Discovery;..\Terceros\myconfig;..\Terceros\binario
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: system_stm32f4xx.c main.c stm32f4xx_it.c fputc_debug.c
    ../Terceros/myconfig/: myconfig.c
    ../Terceros/binario/: binario.c
  group STM32F4-Discovery
    ../terceros/STM32F4-Discovery_FW_V1.1.0/Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../terceros/STM32F4-Discovery_FW_V1.1.0/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group MDK-ARM
    ../terceros/STM32F4-Discovery_FW_V1.1.0/Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
software components: CMSIS:CORE 4.1.0
